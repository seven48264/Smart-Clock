# Keil uVision project stm31f103.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm31f103
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib;..\driver\st7735;..\driver\esp-at;..\driver\mpu6050;..\app\icon
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group app
    ../app/: board.c main.c delay.c weather.c font_temper_32.c font_time_48.c font_lucky.c font_location.c font_character_16.c
    ../app/icon/: icon_weather_duoyun.c icon_weather_feng.c icon_weather_qing.c icon_weather_xue.c icon_weather_yin.c icon_weather_yu.c icon_location.c
  group driver
    ../driver/: led.c rtc.c timer.c
    ../driver/esp-at/: esp_at.c esp_usart.c
    ../driver/st7735/: lcd_spi.c st7735.c stfonts.c
    ../driver/mpu6050/: mpu6050.c swi2c.c
  group firmware
    ../firmware/cmsis/device/: startup_stm32f10x_xl.s system_stm32f10x.c
    ../firmware/cmsis/core/: core_cm3.c
    ../firmware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
